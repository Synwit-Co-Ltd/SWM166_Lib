# Keil uVision project FreeRTOS.uvprojx, settings and files
target SWM166 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM166x8 Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: FreeRTOS
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1
  c define: CHIP_SWM166
  c include: ..\..\SWM166_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM166_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM166_StdPeriph_Driver\CSL\SWM166_StdPeriph_Driver;.\APP;.\APP\FreeRTOS\include;.\APP\FreeRTOS\portable\RVDS\ARM_CM0
  asm define: CHIP_SWM166
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c
  group FreeRTOS\port
    ./APP/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ./APP/FreeRTOS/portable/MemMang/: heap_4.c
  group CSL\StdPD
    ../../SWM166_StdPeriph_Driver/CSL/SWM166_StdPeriph_Driver/: SWM166_adc.c SWM166_exti.c SWM166_gpio.c SWM166_i2c.c SWM166_pwm.c SWM166_timr.c SWM166_uart.c SWM166_wdt.c SWM166_port.c SWM166_flash.c
  group CSL\CMSIS
    ../../SWM166_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM166.c
    ../../SWM166_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM166.s
